# Keil uVision project PWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: PWM +hex
  AfterMake: ..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc
  group Source
    ../: PWM_simple.c
  group Library
    ../Library/StdDriver/src/: sys.c delay.c uart.c IAP.c eeprom.c
  group Startup
    ../Library/Startup/Keil/: STARTUP.A51
